# Keil uVision project IPMC.uvproj, settings and files
target OLUPD_SUPPORT (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: IPMC +hex
  AfterMake: fromelf.exe --bin -o ./Output/IPMC_OLUPD.bin ./Output/IPMC.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER, OLUPD_SUPPORT
  c include: ..\INC;..\LIB\STM32F2xx_StdPeriph_Driver\inc;..\LIB\CMSIS\Device\ST\STM32F2xx\Include;..\SYS;..\LIB\CMSIS\Include;..\RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000400 size 0x1fc00
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: app.c
  group SRC
    ../SRC/: comp_adc.c comp_fish.c comp_gpio.c comp_i2c.c comp_uart.c flash_if.c IPMC.c olupd.c serve_amf.c ShMC.c startup.c ymodem.c
  group SYS
    ../SYS/: system_stm32f2xx.c startup_stm32f2xx.s stm32f2xx_it.c
  group LIB
    ../LIB/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_adc.c stm32f2xx_i2c.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c stm32f2xx_dma.c stm32f2xx_rcc.c stm32f2xx_gpio.c misc.c stm32f2xx_iwdg.c stm32f2xx_exti.c stm32f2xx_syscfg.c stm32f2xx_flash.c
  group RTOS
    ../RTOS/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
target FLASH_DEBUG (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: as above
  output: IPMC +hex
  AfterMake: fromelf.exe --bin -o ./Output/IPMC_FLASH.bin ./Output/IPMC.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,FLASH_DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target RAM_DEBUG (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: as above
  output: IPMC +hex
  AfterMake: fromelf.exe --bin -o ./Output/IPMC_RAM.bin ./Output/IPMC.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER, RAM_DEBUG
  c include: as above
  asm define: DEBUG_INRAM=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
